Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-CAS-06.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcCovering: Кассета угловая открытый тип
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета угловая открытый тип; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-06; ModelName: Кассета угловая открытый тип; Category: Металлокассета; FixingType: Открытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета угловая открытый тип.STEP; SourceSHA256: bb56bd607075e1e3fd78eeca83846cdb3de36631a1d3240b3e150fa34aef10df; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:51:44; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 589.3 mm; BoundingSizeY: 319.3 mm; BoundingSizeZ: 358.6 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000254855 m3; ExactSolidSurfaceArea: 0.730323 m2; SourceSolidCount: 1; SourceFaceCount: 146
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 589.3 mm; BoundingSizeY: 319.3 mm; BoundingSizeZ: 358.6 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000254855 m3; ExactSolidSurfaceArea: 0.730323 m2
