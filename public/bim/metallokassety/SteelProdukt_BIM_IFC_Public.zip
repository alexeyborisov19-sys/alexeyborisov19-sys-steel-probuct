Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-TRIM-13.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcBuildingElementProxy: Угол внутренний
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Угол внутренний; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-13; ModelName: Угол внутренний; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Угол внутренний.STEP; SourceSHA256: 6ee559af1aa959473da2a9539143d10132040d5e8fb6e3f9abb8fec8a800697b; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:49:19; GeometryRepresentation: IfcTriangulatedFaceSet; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 3000 mm; BoundingSizeY: 50.6 mm; BoundingSizeZ: 50.6 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.00020773 m3; ExactSolidSurfaceArea: 0.834095 m2; SourceSolidCount: 1; SourceFaceCount: 42
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 3000 mm; BoundingSizeY: 50.6 mm; BoundingSizeZ: 50.6 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.00020773 m3; ExactSolidSurfaceArea: 0.834095 m2
