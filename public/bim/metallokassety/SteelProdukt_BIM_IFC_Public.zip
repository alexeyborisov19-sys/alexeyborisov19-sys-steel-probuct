Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-CAS-01.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcCovering: Кассета 0.7мм ЗТ
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета 0.7мм ЗТ; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-01; ModelName: Кассета 0.7мм ЗТ; Category: Металлокассета; FixingType: Закрытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета 0.7мм ЗТ.STEP; SourceSHA256: 00efc66c63a0752e6eeab76d05f0903ee7639d9342c4bb43cb70542076ad4c88; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-09-04T09:25:33; GeometryRepresentation: IfcTriangulatedFaceSet; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 565 mm; BoundingSizeY: 19.7 mm; BoundingSizeZ: 561.957 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000264271 m3; ExactSolidSurfaceArea: 0.756847 m2; SourceSolidCount: 1; SourceFaceCount: 102
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 565 mm; BoundingSizeY: 19.7 mm; BoundingSizeZ: 561.957 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000264271 m3; ExactSolidSurfaceArea: 0.756847 m2
