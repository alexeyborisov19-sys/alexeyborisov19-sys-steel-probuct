Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-CAS-02.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcCovering: Кассета 0.7мм ОТ
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета 0.7мм ОТ; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-02; ModelName: Кассета 0.7мм ОТ; Category: Металлокассета; FixingType: Открытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета 0.7мм ОТ.STEP; SourceSHA256: 6c50a98f97c1b30fc26d39cdc321a3c4e938fb1e67b65b0d005feb4cfa9246dc; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-09-04T09:24:28; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 583.6 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583.6 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000264682 m3; ExactSolidSurfaceArea: 0.758183 m2; SourceSolidCount: 1; SourceFaceCount: 106
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 583.6 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583.6 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000264682 m3; ExactSolidSurfaceArea: 0.758183 m2
