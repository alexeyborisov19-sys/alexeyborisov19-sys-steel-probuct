Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-CAS-03.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcCovering: Кассета 1мм ЗТ
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета 1мм ЗТ; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-03; ModelName: Кассета 1мм ЗТ; Category: Металлокассета; FixingType: Закрытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета 1мм ЗТ.STEP; SourceSHA256: c9d10cb067a953fb46fac6a5e873df1bdc55854327ae72ec7a19fe9a0d7abefe; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-09-04T09:25:03; GeometryRepresentation: IfcTriangulatedFaceSet; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 1190 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 561.433 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000764874 m3; ExactSolidSurfaceArea: 1.53355 m2; SourceSolidCount: 1; SourceFaceCount: 102
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 1190 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 561.433 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000764874 m3; ExactSolidSurfaceArea: 1.53355 m2
