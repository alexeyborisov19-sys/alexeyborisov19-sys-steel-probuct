Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-CAS-05.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcCovering: Кассета угловая закрытый тип
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета угловая закрытый тип; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-05; ModelName: Кассета угловая закрытый тип; Category: Металлокассета; FixingType: Закрытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета угловая закрытый тип.STEP; SourceSHA256: e07d7f40f4efc62f09bb36d82b0b0338263786ec34fae7ef54f0bd3257e7b858; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:51:01; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 500 mm; BoundingSizeY: 300 mm; BoundingSizeZ: 431.433 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000405357 m3; ExactSolidSurfaceArea: 0.813684 m2; SourceSolidCount: 1; SourceFaceCount: 176
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 500 mm; BoundingSizeY: 300 mm; BoundingSizeZ: 431.433 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000405357 m3; ExactSolidSurfaceArea: 0.813684 m2
