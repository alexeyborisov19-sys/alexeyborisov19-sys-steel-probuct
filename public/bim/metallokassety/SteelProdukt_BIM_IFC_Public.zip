Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-TRIM-12.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcBuildingElementProxy: Стартовая планка
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Стартовая планка; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-12; ModelName: Стартовая планка; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Стартовая планка.STEP; SourceSHA256: 7a4a939930a68400edd28eac88f1096ba9d28ab18d1c5e20141c2d75d18ddba8; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:50:33; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 2000 mm; BoundingSizeY: 10.3244 mm; BoundingSizeZ: 36.4335 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.0000978727 m3; ExactSolidSurfaceArea: 0.199914 m2; SourceSolidCount: 1; SourceFaceCount: 24
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 2000 mm; BoundingSizeY: 10.3244 mm; BoundingSizeZ: 36.4335 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.0000978727 m3; ExactSolidSurfaceArea: 0.199914 m2
