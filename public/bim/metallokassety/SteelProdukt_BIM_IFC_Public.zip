Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-TRIM-08.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcBuildingElementProxy: Парапет
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Парапет; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-08; ModelName: Парапет; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Парапет.STEP; SourceSHA256: 1c6cde5a716cdeb9d7602f4a4b2df2b69e1bb4b027f5430bed74083939f5b338; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:48:41; GeometryRepresentation: IfcTriangulatedFaceSet; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 2000 mm; BoundingSizeY: 100 mm; BoundingSizeZ: 500 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000906016 m3; ExactSolidSurfaceArea: 2.59236 m2; SourceSolidCount: 1; SourceFaceCount: 28
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 2000 mm; BoundingSizeY: 100 mm; BoundingSizeZ: 500 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000906016 m3; ExactSolidSurfaceArea: 2.59236 m2
