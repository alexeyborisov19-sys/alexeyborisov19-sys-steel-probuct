Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-TRIM-07.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcBuildingElementProxy: Откос
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Откос; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-07; ModelName: Откос; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Откос.STEP; SourceSHA256: 373b729aa587b923564a0f96f48abb3468ba1c5683c6b49de9280d35304df853; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:48:04; GeometryRepresentation: IfcTriangulatedFaceSet; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 1400 mm; BoundingSizeY: 119.3 mm; BoundingSizeZ: 120 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000232412 m3; ExactSolidSurfaceArea: 0.66635 m2; SourceSolidCount: 1; SourceFaceCount: 26
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 1400 mm; BoundingSizeY: 119.3 mm; BoundingSizeZ: 120 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000232412 m3; ExactSolidSurfaceArea: 0.66635 m2
