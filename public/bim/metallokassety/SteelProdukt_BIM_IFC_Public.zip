Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-CAS-09.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcCovering: Стандартная кассета 1 сливное
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Стандартная кассета 1 сливное; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-09; ModelName: Стандартная кассета 1 сливное; Category: Металлокассета; FixingType: Не указан в имени исходного файла; DrainHolesFromFileName: 1; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Стандартная кассета 1 сливное.STEP; SourceSHA256: c41d17aae19c0f26c1326c157afba355a43ba537948ffa4f5bc0939c655a4190; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:52:27; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 348 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 368 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000148848 m3; ExactSolidSurfaceArea: 0.299581 m2; SourceSolidCount: 1; SourceFaceCount: 108
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 348 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 368 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000148848 m3; ExactSolidSurfaceArea: 0.299581 m2
