Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-TRIM-14.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcBuildingElementProxy: Угол
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Угол; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-14; ModelName: Угол; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Угол.STEP; SourceSHA256: c4a143421df3dd6879a89166fcb136ba741fe66deef2f18cf687cc268b6c5f46; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:49:56; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 2500 mm; BoundingSizeY: 30 mm; BoundingSizeZ: 20 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.0000795769 m3; ExactSolidSurfaceArea: 0.320887 m2; SourceSolidCount: 1; SourceFaceCount: 26
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 2500 mm; BoundingSizeY: 30 mm; BoundingSizeZ: 20 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.0000795769 m3; ExactSolidSurfaceArea: 0.320887 m2
