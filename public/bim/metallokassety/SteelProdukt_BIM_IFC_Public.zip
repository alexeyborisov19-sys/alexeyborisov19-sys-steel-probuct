Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SteelProdukt_Catalog_IFC4_Exact.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcBuildingElementProxy: Откос
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Откос; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-07; ModelName: Откос; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Откос.STEP; SourceSHA256: 373b729aa587b923564a0f96f48abb3468ba1c5683c6b49de9280d35304df853; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:48:04; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 1400 mm; BoundingSizeY: 119.3 mm; BoundingSizeZ: 120 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000232412 m3; ExactSolidSurfaceArea: 0.66635 m2; SourceSolidCount: 1; SourceFaceCount: 26
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 1400 mm; BoundingSizeY: 119.3 mm; BoundingSizeZ: 120 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000232412 m3; ExactSolidSurfaceArea: 0.66635 m2

# IfcBuildingElementProxy: Парапет
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Парапет; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-08; ModelName: Парапет; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Парапет.STEP; SourceSHA256: 1c6cde5a716cdeb9d7602f4a4b2df2b69e1bb4b027f5430bed74083939f5b338; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:48:41; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 2000 mm; BoundingSizeY: 100 mm; BoundingSizeZ: 500 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000906016 m3; ExactSolidSurfaceArea: 2.59236 m2; SourceSolidCount: 1; SourceFaceCount: 28
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 2000 mm; BoundingSizeY: 100 mm; BoundingSizeZ: 500 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000906016 m3; ExactSolidSurfaceArea: 2.59236 m2

# IfcBuildingElementProxy: Стартовая планка
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Стартовая планка; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-12; ModelName: Стартовая планка; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Стартовая планка.STEP; SourceSHA256: 7a4a939930a68400edd28eac88f1096ba9d28ab18d1c5e20141c2d75d18ddba8; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:50:33; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 2000 mm; BoundingSizeY: 10.3244 mm; BoundingSizeZ: 36.4335 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.0000978727 m3; ExactSolidSurfaceArea: 0.199914 m2; SourceSolidCount: 1; SourceFaceCount: 24
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 2000 mm; BoundingSizeY: 10.3244 mm; BoundingSizeZ: 36.4335 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.0000978727 m3; ExactSolidSurfaceArea: 0.199914 m2

# IfcBuildingElementProxy: Угол
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Угол; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-14; ModelName: Угол; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Угол.STEP; SourceSHA256: c4a143421df3dd6879a89166fcb136ba741fe66deef2f18cf687cc268b6c5f46; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:49:56; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 2500 mm; BoundingSizeY: 30 mm; BoundingSizeZ: 20 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.0000795769 m3; ExactSolidSurfaceArea: 0.320887 m2; SourceSolidCount: 1; SourceFaceCount: 26
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 2500 mm; BoundingSizeY: 30 mm; BoundingSizeZ: 20 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.0000795769 m3; ExactSolidSurfaceArea: 0.320887 m2

# IfcBuildingElementProxy: Угол внутренний
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Угол внутренний; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-13; ModelName: Угол внутренний; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Угол внутренний.STEP; SourceSHA256: 6ee559af1aa959473da2a9539143d10132040d5e8fb6e3f9abb8fec8a800697b; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:49:19; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 3000 mm; BoundingSizeY: 50.6 mm; BoundingSizeZ: 50.6 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.00020773 m3; ExactSolidSurfaceArea: 0.834095 m2; SourceSolidCount: 1; SourceFaceCount: 42
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 3000 mm; BoundingSizeY: 50.6 mm; BoundingSizeZ: 50.6 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.00020773 m3; ExactSolidSurfaceArea: 0.834095 m2

# IfcBuildingElementProxy: отлив
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: отлив; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-15; ModelName: отлив; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: отлив.STEP; SourceSHA256: 724931a504f95fe39cf1095c9642b4e2d5152c2930f3a41532079e6ec2a73f5d; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:46:42; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 2000 mm; BoundingSizeY: 241.481 mm; BoundingSizeZ: 123.508 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.000327706 m3; ExactSolidSurfaceArea: 1.31317 m2; SourceSolidCount: 1; SourceFaceCount: 34
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 2000 mm; BoundingSizeY: 241.481 mm; BoundingSizeZ: 123.508 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.000327706 m3; ExactSolidSurfaceArea: 1.31317 m2

# IfcCovering: Кассета 0.7мм ЗТ
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета 0.7мм ЗТ; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-01; ModelName: Кассета 0.7мм ЗТ; Category: Металлокассета; FixingType: Закрытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета 0.7мм ЗТ.STEP; SourceSHA256: 00efc66c63a0752e6eeab76d05f0903ee7639d9342c4bb43cb70542076ad4c88; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-09-04T09:25:33; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 565 mm; BoundingSizeY: 19.7 mm; BoundingSizeZ: 561.957 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000264271 m3; ExactSolidSurfaceArea: 0.756847 m2; SourceSolidCount: 1; SourceFaceCount: 102
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 565 mm; BoundingSizeY: 19.7 mm; BoundingSizeZ: 561.957 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000264271 m3; ExactSolidSurfaceArea: 0.756847 m2

# IfcCovering: Кассета 0.7мм ОТ
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета 0.7мм ОТ; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-02; ModelName: Кассета 0.7мм ОТ; Category: Металлокассета; FixingType: Открытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета 0.7мм ОТ.STEP; SourceSHA256: 6c50a98f97c1b30fc26d39cdc321a3c4e938fb1e67b65b0d005feb4cfa9246dc; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-09-04T09:24:28; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 583.6 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583.6 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000264682 m3; ExactSolidSurfaceArea: 0.758183 m2; SourceSolidCount: 1; SourceFaceCount: 106
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 583.6 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583.6 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000264682 m3; ExactSolidSurfaceArea: 0.758183 m2

# IfcCovering: Кассета 1мм ЗТ
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета 1мм ЗТ; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-03; ModelName: Кассета 1мм ЗТ; Category: Металлокассета; FixingType: Закрытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета 1мм ЗТ.STEP; SourceSHA256: c9d10cb067a953fb46fac6a5e873df1bdc55854327ae72ec7a19fe9a0d7abefe; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-09-04T09:25:03; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 1190 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 561.433 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000764874 m3; ExactSolidSurfaceArea: 1.53355 m2; SourceSolidCount: 1; SourceFaceCount: 102
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 1190 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 561.433 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000764874 m3; ExactSolidSurfaceArea: 1.53355 m2

# IfcCovering: Кассета 1мм ОТ
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета 1мм ОТ; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-04; ModelName: Кассета 1мм ОТ; Category: Металлокассета; FixingType: Открытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета 1мм ОТ.STEP; SourceSHA256: 54bb19c173773866a6a0e16344e21bab225dffb263a68c1795bb12207f5e1309; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-09-04T09:23:54; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 1208 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000762583 m3; ExactSolidSurfaceArea: 1.52919 m2; SourceSolidCount: 1; SourceFaceCount: 106
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 1208 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000762583 m3; ExactSolidSurfaceArea: 1.52919 m2

# IfcCovering: Кассета угловая закрытый тип
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета угловая закрытый тип; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-05; ModelName: Кассета угловая закрытый тип; Category: Металлокассета; FixingType: Закрытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета угловая закрытый тип.STEP; SourceSHA256: e07d7f40f4efc62f09bb36d82b0b0338263786ec34fae7ef54f0bd3257e7b858; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:51:01; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 500 mm; BoundingSizeY: 300 mm; BoundingSizeZ: 431.433 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000405357 m3; ExactSolidSurfaceArea: 0.813684 m2; SourceSolidCount: 1; SourceFaceCount: 176
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 500 mm; BoundingSizeY: 300 mm; BoundingSizeZ: 431.433 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000405357 m3; ExactSolidSurfaceArea: 0.813684 m2

# IfcCovering: Кассета угловая открытый тип
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Кассета угловая открытый тип; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-06; ModelName: Кассета угловая открытый тип; Category: Металлокассета; FixingType: Открытый тип (по имени исходника); MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Кассета угловая открытый тип.STEP; SourceSHA256: bb56bd607075e1e3fd78eeca83846cdb3de36631a1d3240b3e150fa34aef10df; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:51:44; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 589.3 mm; BoundingSizeY: 319.3 mm; BoundingSizeZ: 358.6 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000254855 m3; ExactSolidSurfaceArea: 0.730323 m2; SourceSolidCount: 1; SourceFaceCount: 146
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 589.3 mm; BoundingSizeY: 319.3 mm; BoundingSizeZ: 358.6 mm; MeasuredSheetThickness: 0.7 mm; ExactSolidVolume: 0.000254855 m3; ExactSolidSurfaceArea: 0.730323 m2

# IfcCovering: Стандартная кассета 1 сливное
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Стандартная кассета 1 сливное; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-09; ModelName: Стандартная кассета 1 сливное; Category: Металлокассета; FixingType: Не указан в имени исходного файла; DrainHolesFromFileName: 1; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Стандартная кассета 1 сливное.STEP; SourceSHA256: c41d17aae19c0f26c1326c157afba355a43ba537948ffa4f5bc0939c655a4190; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:52:27; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 348 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 368 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000148848 m3; ExactSolidSurfaceArea: 0.299581 m2; SourceSolidCount: 1; SourceFaceCount: 108
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 348 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 368 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000148848 m3; ExactSolidSurfaceArea: 0.299581 m2

# IfcCovering: Стандартная кассета 2 сливных
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Стандартная кассета 2 сливных; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-10; ModelName: Стандартная кассета 2 сливных; Category: Металлокассета; FixingType: Не указан в имени исходного файла; DrainHolesFromFileName: 2; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Стандартная кассета 2 сливных.STEP; SourceSHA256: 994bf269f26b6a27bea54a3a482181ba02fcf29229607366a38de6db6d7b921b; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:53:13; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 678 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000435076 m3; ExactSolidSurfaceArea: 0.873138 m2; SourceSolidCount: 1; SourceFaceCount: 110
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 678 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000435076 m3; ExactSolidSurfaceArea: 0.873138 m2

# IfcCovering: Стандартная кассета 3 сливных
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Стандартная кассета 3 сливных; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-11; ModelName: Стандартная кассета 3 сливных; Category: Металлокассета; FixingType: Не указан в имени исходного файла; DrainHolesFromFileName: 3; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Стандартная кассета 3 сливных.STEP; SourceSHA256: fb6aa9ed911778aab5bad70ae5b356b3b51b6bc96ede5bb06e95c1f6f1a090cf; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:53:32; GeometryRepresentation: IfcAdvancedBrep; PreservedOriginalAxes: yes; DisplayArrangementOnly: yes
Type - SP_Geometry - BoundingSizeX: 1018 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000645159 m3; ExactSolidSurfaceArea: 1.29399 m2; SourceSolidCount: 1; SourceFaceCount: 112
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 1018 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000645159 m3; ExactSolidSurfaceArea: 1.29399 m2
