Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-TRIM-15.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcBuildingElementProxy: отлив
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: отлив; PredefinedType: USERDEFINED
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-TRIM-15; ModelName: отлив; Category: Доборный элемент; FixingType: Не указан в имени исходного файла; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: отлив.STEP; SourceSHA256: 724931a504f95fe39cf1095c9642b4e2d5152c2930f3a41532079e6ec2a73f5d; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:46:42; GeometryRepresentation: IfcTriangulatedFaceSet; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 2000 mm; BoundingSizeY: 241.481 mm; BoundingSizeZ: 123.508 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.000327706 m3; ExactSolidSurfaceArea: 1.31317 m2; SourceSolidCount: 1; SourceFaceCount: 34
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 2000 mm; BoundingSizeY: 241.481 mm; BoundingSizeZ: 123.508 mm; MeasuredSheetThickness: 0.5 mm; ExactSolidVolume: 0.000327706 m3; ExactSolidSurfaceArea: 1.31317 m2
