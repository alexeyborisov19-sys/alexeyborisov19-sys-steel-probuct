Properties of the parts of a building model (IFC4)

# File
Description: IFC4 library; supplied STEP geometry; not a certified model view
File name: SP-CAS-11.ifc
Time: 2026-10-14T00:00:00
Author: Steel Produkt BIM export
Organization: Steel Produkt
Written by: STEP geometry mapping / OpenCascade
Made in: SP IFC4 exporter 1.0

# IfcProject, Сталь Продукт — BIM-библиотека
Description: Каталог отдельных изделий, не проект фасада

# IfcBuildingStorey, Образцы моделей
In: Каталог, не реальное здание
Elevation: 0 mm

# IfcCovering: Стандартная кассета 3 сливных
In: Образцы моделей
Type - Description: Типоразмер из предоставленного STEP-файла; ElementType: Стандартная кассета 3 сливных; PredefinedType: CLADDING
Type - SP_Product - LibraryOwner: Сталь Продукт; ModelId: SP-CAS-11; ModelName: Стандартная кассета 3 сливных; Category: Металлокассета; FixingType: Не указан в имени исходного файла; DrainHolesFromFileName: 3; MaterialStatus: Марка и плотность материала не заданы в исходнике; CoatingStatus: Покрытие и RAL не заданы в исходнике; ParametricSizeEditing: no; UseStatus: Для BIM-координации; не выпуск в производство
Type - SP_Source - SourceFile: Стандартная кассета 3 сливных.STEP; SourceSHA256: fb6aa9ed911778aab5bad70ae5b356b3b51b6bc96ede5bb06e95c1f6f1a090cf; SourceLengthUnit: mm; SourceSchema: CONFIG_CONTROL_DESIGN / STEP AP203; SourceApplication: SolidWorks 2024; SourceExportDate: 2026-10-13T09:53:32; GeometryRepresentation: IfcTriangulatedFaceSet; PreservedOriginalAxes: yes; DisplayArrangementOnly: no
Type - SP_Geometry - BoundingSizeX: 1018 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000645159 m3; ExactSolidSurfaceArea: 1.29399 m2; SourceSolidCount: 1; SourceFaceCount: 112
Description: Геометрия исходного STEP; без параметрической перестройки
SP_GeometricQuantities - BoundingSizeX: 1018 mm; BoundingSizeY: 20 mm; BoundingSizeZ: 583 mm; MeasuredSheetThickness: 1 mm; ExactSolidVolume: 0.000645159 m3; ExactSolidSurfaceArea: 1.29399 m2
